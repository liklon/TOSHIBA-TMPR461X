# Keil uVision project graphics.uvproj, settings and files
target graphics (5050169::V5.05 update 2 (build 169)::.\ARMCC_505u2)
  device: Cortex-R4 ARM
  cpu: CLOCK(160000000) CPUTYPE("Cortex-R4") ESEL EBIG
  output: graphics +hex
  BeforeMake: cmd.exe /c del /F "$L@L.*"
  AfterMake: fromelf --bincombined --bincombined_base=0x02100000  --output  "$L@L.bin"  "#L"
  AfterMake: fromelf.exe --m32 --output  "$L@L.s32"  "#L"
  c flags: Optim=1
  c define: __KEIL__
  c include: ..\..\inc;..\..\..\..\common\inc;..\..\..\..\cortex_r4_keil\inc;..\..\..\..\hldd\inc;..\..\..\..\lldd\inc;..\..\..\..\lldd\hdr;..\..\..\..\mw\inc;..\..\usecases\inc;..\..\usecases\images\inc
  asm include: ..\..\..\..\cortex_r4_keil\inc
  memory RVCT1: ROM 0x2010000 size 0x1000000
  memory RVCT6: RAM 0x40000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x10000
  memory RVCT10: RAM 0x800000 size 0xc0000
  scatter file: ..\\graphics.scat
  link misc: --remove
--symdefs=graphics.sym
  group A__Z
    ../../Pictures/A__Z/: AA0.c AA1.c AA2.c AA3.c AA4.c AA5.c AA6.c AA7.c AA8.c AA9.c AA10.c AA11.c AA12.c AA13.c AA14.c AA15.c AA16.c AA17.c AA18.c AA19.c AA20.c AA21.c AA22.c AA23.c AA24.c AA25.c
  group a_z
    ../../Pictures/a_z/: a0.c a1.c a2.c a3.c a4.c a5.c a6.c a7.c a8.c a9.c a10.c a11.c a12.c a13.c a14.c a15.c a16.c a17.c a18.c a19.c a20.c a21.c a22.c a23.c a24.c a25.c
  group car_door
    ../../Pictures/car_door/: door_d1.c door_d2.c door_d3.c door_d4.c door_d5.c door_d6.c door_d7.c door_d8.c door_d9.c door_d10.c door_d11.c door_d12.c door_d13.c door_d14.c door_d15.c
  group disfont_14x
    ../../Pictures/disfont_14x/: disfont0.c disfont1.c disfont2.c disfont3.c disfont4.c disfont5.c disfont6.c disfont7.c disfont8.c disfont9.c disfont10.c
  group err_word
    ../../Pictures/err_word/: ERR1.c ERR2.c ERR3.c ERR4.c ERR5.c ERR6.c ERR7.c ERR8.c ERR9.c ERR10.c ERR11.c ERR12.c ERR13.c ERR14.c ERR15.c ERR16.c ERR17.c ERR18.c ERR19.c
  group instrument
    ../../Pictures/instrument/: dial_amp.c dial_soc.c dial_speed.c
  group lamp
    ../../Pictures/lamp/: sspic0.c sspic1.c sspic2.c sspic3.c sspic4.c sspic5.c sspic6.c sspic7.c sspic8.c sspic9.c sspic10.c sspic11.c sspic12.c sspic13.c sspic14.c sspic15.c sspic16.c sspic17.c sspic18.c sspic19.c sspic20.c sspic21.c sspic22.c sspic23.c sspic24.c sspic25.c sspic26.c
  group prnds
    ../../Pictures/prnds/: LEV_D.c LEV_N.c LEV_P.c LEV_R.c LEV_S.c
  group speedfont
    ../../Pictures/speedfont/: speedfont0.c speedfont1.c speedfont2.c speedfont3.c speedfont4.c speedfont5.c speedfont6.c speedfont7.c speedfont8.c speedfont9.c
  group needle
    ../../Pictures/needle/: needle_amp.c needle_speed.c
