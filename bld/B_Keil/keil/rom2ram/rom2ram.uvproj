# Keil uVision project rom2ram.uvproj, settings and files
target rom2ram (5050169::V5.05 update 2 (build 169)::.\ARMCC_505u2)
  device: Cortex-R4 ARM
  cpu: CLOCK(160000000) CPUTYPE("Cortex-R4") ESEL EBIG
  output: rom2ram +hex
  AfterMake: fromelf --bincombined --bincombined_base=0x2010000  --output  "$L@L.bin"  "#L"
  AfterMake: fromelf.exe --m32 --output  "$L@L.s32"  "#L"
  c flags: Optim=1
  c define: __KEIL__,__DBG_ITM
  c include: ..\..\inc;..\..\usecases\inc;..\..\..\..\common\inc;..\..\..\..\cortex_r4_keil\inc;..\..\..\..\hldd\inc;..\..\..\..\lldd\inc;..\..\..\..\lldd\hdr;..\..\..\..\mw\inc;..\..\usecases\images\inc;..\..\..\..\cortex_r4\inc;..\..\src
  asm include: ..\..\..\..\cortex_r4_keil\inc
  memory RVCT1: ROM 0x2010000 size 0x1000000
  memory RVCT6: RAM 0x40000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x10000
  memory RVCT10: RAM 0x800000 size 0xc0000
  scatter file: ..\rom2ram.scat
  link misc: --remove
  group mw
    ../../../../mw/src/: fbuffer.c gfunctions.c graphics_init.c layer.c listmngr.c rotation.c
  group lldd
    ../../../../lldd/src/: adc.c blit.c ccr.c dmac.c dmc.c draw.c esei.c fg.c ga.c gdc.c gpio.c hsuart.c iic.c iic_timer.c iis.c intc.c pl353nand.c pl353nor.c png.c qspic.c rotation_matrix.c rtc.c sin_cos.c smc.c stpu.c timer_cmplx.c timer_gdc_pwm.c timer_hs_pwm.c timer_pwm.c transf.c txcan.c wdt.c pl353_rw_support.s qspic_rw_support.s
  group hldd
    ../../../../hldd/src/: charled.c pl353_nandflash.c pl353_norflash.c qspi.c dmc_cfg.c
  group cortex_r4_keil
    ../../../../cortex_r4_keil/src/: core_bootloader_keil.s core_init_keil.s cr4_burst_access_keil.s cr4_pmu_keil.s excp_hndlr_keil.s rom_copy_keil.s
  group common
    ../../../../common/src/: copy_functions.s core.s
  group images
    ../../usecases/images/src/: images_copy_rom_to_ram.c images_init.c images_ram_arrays.c images_ram_structs.c
  group graphics
    ../out/: graphics.sym
  group src
    ../../src/: boardcfg.c main.c pinconfig.c mydef.h myconfig.c mymenu.c myfont.c
  group usecases
    ../../usecases/src/: icons.c statevariables.c buttons.c can.c
target ram (ARM-ADS)
  device: Cortex-R4 ARM
  cpu: CLOCK(160000000) CPUTYPE("Cortex-R4") ESEL EBIG
  output: ram +hex
  c flags: Optim=1
  c define: __KEIL__, MEASURE_TX,
  c include: ..\..\inc;..\..\usecases\inc;..\..\..\..\common\inc;..\..\..\..\cortex_r4_keil\inc;..\..\..\..\freetype\inc;..\..\..\..\hldd\inc;..\..\..\..\lldd\inc;..\..\..\..\lldd\hdr;..\..\..\..\mw\inc;..\..\usecases\images\inc;..\..\..\..\cortex_r4\inc;..\..\src
  asm include: ..\..\..\..\cortex_r4_keil\inc
  memory RVCT1: ROM 0x2010000 size 0x1000000
  memory RVCT6: RAM 0x40000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x10000
  memory RVCT10: RAM 0x800000 size 0xc0000
  scatter file: ..\ram.scat
  link misc: --remove
